# IAR project codebrick.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xD ST STM32F401xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\User; ..\lib\CMSIS\Include; ..\lib\CMSIS\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\framework; ..\driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: codebrick.srec
  ILINK.IlinkOutputFile: codebrick.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../driver/src/: mcu_flash.c tty.c
  group framework
    ../framework/: blink.c cli.c key.c module.c pm.c queue.c ringbuffer.c
  group lib/CMSIS
    ../lib/CMSIS/STM32F4xx/Source/iar/: startup_stm32f4xx.s
    ../lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group lib/STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group user
    ../user/: config.h led.c main.c platform - lowpower.c platform.c public.c stm32f4xx_conf.h stm32f4xx_it.c
  group user/cmd
    ../user/cmd/: cmd_devinfo.c cmd_pm.c
  group user/task
    ../user/task/: cli_task.c key_task.c
